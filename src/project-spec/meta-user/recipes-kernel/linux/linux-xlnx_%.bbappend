FILESEXTRAPATHS_prepend := "${THISDIR}/linux-xlnx:"

SRC_URI += "file://0001-axidma-set-SOP-EOP-on-S2MM-SG-descriptors.patch"
